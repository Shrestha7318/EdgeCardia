# Keil uVision project heart-beat.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: heart-beat
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c random_forest.h filters.h normalization.h thresholds.h filters.c ecg_hardware.h ecg_hardware.c ssd1306_fonts.c ssd1306_fonts.h ssd1306.c ssd1306.h i2c.h i2c.c display_ui.h display_ui.c ssd1306_conf.h esp01s.c esp01s.h net_config.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.3
